# Keil uVision project GMOTE.uvprojx, settings and files
target GMOTE Configuration (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GMOTE Configuration
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;                   ..\Drivers\STM32F4xx_HAL_Driver\Inc;                   ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;                   ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;                   ..\Middlewares\Third_Party\FreeRTOS\Source\include;                   ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;                   ..\Drivers\CMSIS\Include;                   ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c timers.c event_groups.c queue.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c freertos.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c
  group GMote
    ../Src/: comunication.c GMoteISR.c sensorAq.c keypad.c processing.c
  group Sensors
    ../Src/: sensor.c mpu6050_gyro.c GyroAq.c AccelerometerAq.c Accelerometer.c
  group Processing
    ../Src/: codebook.c HMM_param.c HMM.c kdtree.c simpleProcessing.c codebook_param.c
  group Comunication
    ../Src/: retarget.c nrf24l01.c
  group DSP
    ../Drivers/CMSIS/DSP_Lib/Lib/: arm_cortexM4lf_math.lib
  group Tools
    ../Src/: error.c usDelay.c
